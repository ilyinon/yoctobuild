require recipes-debian/gcc/gcc-cross_${PV}.bb
require gcc-cross-initial.inc
