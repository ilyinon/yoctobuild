require recipes-debian/gcc/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

