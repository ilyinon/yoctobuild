require recipes-debian/gcc/gcc-${PV}.inc
require recipes-debian/gcc/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
