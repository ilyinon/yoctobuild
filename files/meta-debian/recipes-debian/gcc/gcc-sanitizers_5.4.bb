require recipes-debian/gcc/gcc-${PV}.inc
require gcc-sanitizers.inc
