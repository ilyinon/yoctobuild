require recipes-debian/gcc/gcc-${PV}.inc
require libgfortran.inc

