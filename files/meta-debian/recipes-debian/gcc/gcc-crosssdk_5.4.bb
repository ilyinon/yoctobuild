require recipes-debian/gcc/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
