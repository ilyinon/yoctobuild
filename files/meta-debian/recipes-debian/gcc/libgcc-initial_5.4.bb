require recipes-debian/gcc/gcc-${PV}.inc
require libgcc-initial.inc
