require recipes-debian/gcc/gcc-${PV}.inc
require gcc-cross-canadian.inc



